# Repository CREATE-ROCKET/Avi_103J_log_sep_sinnsasyo_program

File README.md:

# CREATE Rocket ESP32 S3 template

> [!WARNING]
> Kicad v9を用いて作成したため、これ以下のバージョンのkicadだと動きません

ESP32 S3を動作させるのに必要な最低限のものだけ実装したプロジェクトです。

これを変更することで、より高度なものを作ることができます。

## 使用部品
| 部品名                     | 個数 | url                                                                              |
| -------------------------- | ---- | -------------------------------------------------------------------------------- |
| ESP32 S3 WROOM 1           | 1    | https://akizukidenshi.com/catalog/g/g117256/                                     |
| RT9080 3.3V レギュレーター | 1    | https://akizukidenshi.com/catalog/g/g129588/                                     |
| Type C 基板実装用          | 1    | https://akizukidenshi.com/catalog/g/g114356/                                     |  |
| USBLC6-25C6                | 1    | https://www.digikey.jp/ja/products/detail/stmicroelectronics/USBLC6-2SC6/1040559 |
| LM66100DCKR                | 1    | https://www.digikey.jp/ja/products/detail/texas-instruments/LM66100DCKR/10273183 |
| 1608 コンデンサ 0.1uF      | 2    | https://akizukidenshi.com/catalog/g/g113374/                                     |
| 1608 コンデンサ 10uF       | 2    | https://akizukidenshi.com/catalog/g/g113161/                                     |
| 1608 抵抗 10k              | 1    | https://akizukidenshi.com/catalog/g/g130355/                                     |
| 1608 抵抗 5.1k (4.7k)      | 2    | https://akizukidenshi.com/catalog/g/g130353/                                     |
| タクトスイッチ             | 2    | https://akizukidenshi.com/catalog/g/g103647/                                     |

## KiCad design kicad/Avi_ESP32S3_template.kicad_pcb

Parts:
C2, C5: 0.1u; C_0603_1608Metric
C3, C4: 10μ; C_0603_1608Metric
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
R1, R4: 10k; C_0603_1608Metric
R2, R3: 5.1k; C_0603_1608Metric
SW1, SW2: SW_Push; SW_PUSH_6mm_H7.3mm
U1: ESP32-S3-WROOM-1
U2: RT9080; TSOT-23-5
U3: USBLC6-2SC6; SOT-23-6
U4: LM66100DCK; SOT-363_SC-70-6

Connections:
+3.3V: C4.1, C5.2, R1.1, U1.2 (3V3), U2.5 (VOUT)
/5V: C3.1, U2.1 (VIN), U2.3 (INH), U3.5 (VBUS), U4.3 (~CE), U4.6 (VOUT)
/IO0: SW2.2, U1.27 (IO0)
/USB_VCC: J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U4.1 (VIN)
/esp_usb_m: U1.13 (USB_D-), U3.6 (I/O1)
/esp_usb_p: U1.14 (USB_D+), U3.4 (I/O2)
/usb_m: J1.A7 (D-), J1.B7 (D-), U3.1 (I/O1)
/usb_p: J1.A6 (D+), J1.B6 (D+), U3.3 (I/O2)
GND: C2.2, C3.2, C4.2, C5.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), R2.2, R3.2, R4.1, SW1.1, SW2.1, U1.1 (GND), U1.40 (GND), U1.41 (GND), U2.2 (GND), U2.4 (BYP), U3.2 (GND), U4.2 (GND)
unnamed: J1.A5 (CC1), R2.1
unnamed: J1.B5 (CC2), R3.1
unnamed: C2.1, R1.2, SW1.2, U1.3 (EN)
unnamed: R4.2, U4.5 (ST)

Notes on the sheet:
surge
Ideal Diode
ツェナーダイオードの寄生容量は0.5pF以下が必要
type C
ENピンは1でon、0でoffです IO0は内部でweak pull upされているので、pull downされていないときは内蔵SPIからbootされて、 IO0がGNDに落ちている&IO46がpull upされていないならUSB&UART download modeになります (IO46は内部でweak pull downされているので、pull up等してなければ良い)
power
esp32 s3

Board: 2 copper layers, 48.0 x 27.0 mm, 15 parts (0 on the bottom side), 13 nets.
